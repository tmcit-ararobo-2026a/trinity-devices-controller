# Repository tmcit-ararobo-2026a/trinity-devices-controller

File README.md:

# Trinity Devices Controller

高出力12Vを生成し、各種デバイスを駆動するモジュール。

## 目次

1. [概要](#1-概要)
2. [ドキュメント](#2-ドキュメント)
3. [ビルド・使い方](#3-ビルド使い方)
4. [システム構成](#4-システム構成)
5. [ライセンス](#5-ライセンス)

## 1. 概要

電磁弁やDCファンなどを動作可能。
gn10-canプロトコルに準拠しCAN通信で操作可能。

## 2. ドキュメント

| ドキュメント | 説明 |
| :-: | :-: |
| [CONTRIBUTING.md](./CONTRIBUTING.md) | 開発フロー・コミット規約・コーディング規約 |
| [docs/coding-rules.md](./docs/coding-rules.md) | コーディング規約の詳細 |
| [docs/uml/](./docs/uml/) | UML図 |

## 3. ビルド・使い方

1. ファームウェアのビルド

2. STLinkによる書き込み

## 4. システム構成

## 5. ライセンス

本リポジトリは [MITライセンス](./LICENSE) のもとで公開されています。

## KiCad design trinity-devices-controller_24V/trinity-devices-controller_24V.kicad_pcb

Parts:
C1, C6: 10uf; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C7: 10n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C4, C5, C8, C9, C10: 10uf; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C11, C12, C13, C14: 470uf; CP_Radial_D10.0mm_P5.00mm
C20, C21, C22, C23, C24, C25, C26: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C27: 0.47u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C28: 1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C29: 0.1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2, D3, D4, D9, D10, D27, D28, D29, D30: SS2040FL; SOD-123FL
D5, D6, D7, D8, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D24, D25, D26: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
F1, F2: SF-1206FP100-2; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
IC2: MCP2562; SOIC127P600X175-8N; Mouser Part Number 771-TJA1441AT/0Z
J1, J2, J9, J10, J16, J17, J18, J19: xh2pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J3, J4: Conn_01x01_Pin; PV_3
J5, J6, J8: Conn_01x04; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
J7: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
JP1: Jumper_2_Open; TestPoint_2Pads_Pitch2.54mm_Drill0.8mm
L1, L2: 10uH; L_Taiyo-Yuden_MD-5050
Q1, Q2, Q5, Q6, Q8, Q9, Q10, Q11: SSM6K819R; TSOP6F
R1, R2, R5, R6, R16, R18, R20, R21, R23, R56, R57, R58, R59, R64, R65, R66, R67: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4, R19, R22, R60, R61, R62, R63: 100; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R10: 47k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8, R11: 2.4k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9, R12: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13, R14, R15, R24, R32, R33, R34, R35, R40, R42, R43, R44, R45, R46, R47, R48, R53, R54, R55: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R17: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_Push; switch_TVAF06-A020B-R
U1, U5: TLP293-4; SOIC-16_4.55x10.3mm_P1.27mm
U2, U7: NJW4132U2-B; SOT-89-5_Handsoldering
U3: STM32G431K8Tx; LQFP-32_7x7mm_P0.8mm
U4: NJM12888F33; SOT-23-5_HandSoldering
U6: NJM7812SDL1; TO-252-2

Connections:
24V_1: C2.2, C3.1, C4.1, C5.1, C11.1, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D9.1 (K), J1.2, J2.2, J9.2, J10.2, R7.1, R13.1
24V_2: C7.2, C8.1, C9.1, C10.1, C12.1, D10.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), J16.2, J17.2, J18.2, J19.2, R10.1, R14.1
+3.3V: C20.1, C21.1, C23.1, C25.1, C27.1, IC2.5 (VIO), J7.4, J8.2, R43.1, U3.1 (VDD), U3.15 (VDDA), U3.17 (VDD), U4.5 (VOUT)
+5V: C24.1, C26.1, IC2.3 (VCC), J5.3, J6.3, R44.1, U4.1 (VIN), U4.3 (CONTROL)
+12V: C29.1, R40.1, U1.10, U1.12, U1.14, U1.16, U5.10, U5.12, U5.14, U5.16, U6.3 (VOUT)
CANH: IC2.7 (CANH), J5.4, J6.4, R17.1
CANL: IC2.6 (CANL), J5.2, J6.2, JP1.2 (B)
CAN_RX: IC2.4 (RXD), U3.21 (PA11)
CAN_TX: IC2.1 (TXD), U3.22 (PA12)
GND: C1.2, C3.2, C4.2, C5.2, C6.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C28.2, C29.2, D11.1 (K), D12.1 (K), D13.1 (K), D15.1 (K), J4.1, Q1.4 (S), Q2.4 (S), Q5.4 (S), Q6.4 (S), Q8.4 (S), Q9.4 (S), Q10.4 (S), Q11.4 (S), R5.2, R6.2, R9.1, R12.1, R15.2, R20.2, R23.2, R24.2, R64.2, R65.2, R66.2, R67.2, U2.2 (GND), U6.2 (GND), U7.2 (GND)
GNDD: C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), IC2.2 (GND), IC2.8 (S), J5.1, J6.1, J7.2, J8.4, R16.1, SW1.1, U1.2, U1.4, U1.6, U1.8, U3.14 (VSSA), U3.16 (VSS), U3.32 (VSS), U4.2 (GND), U5.2, U5.4, U5.6, U5.8
IN1: R1.1, R32.1, U3.9 (PA4)
IN2: R2.1, R33.1, U3.10 (PA5)
IN3: R18.1, R34.1, U3.11 (PA6)
IN4: R21.1, R35.1, U3.12 (PA7)
IN5: R48.1, R56.1, U3.18 (PA8)
IN6: R53.1, R57.1, U3.19 (PA9)
IN7: R54.1, R58.1, U3.20 (PA10)
IN8: R55.1, R59.1, U3.28 (PB5)
LED1: R45.1, U3.27 (PB4)
LED2: R46.1, U3.25 (PA15)
LED3: R47.1, U3.26 (PB3)
NRST: C22.1, SW1.2, U3.4 (PG10)
unnamed: D5.2 (A), R32.2
unnamed: D6.2 (A), R33.2
unnamed: D7.2 (A), R34.2
unnamed: D8.2 (A), R35.2
unnamed: D9.2 (A), L1.2, U2.1 (SW)
unnamed: D10.2 (A), L2.2, U7.1 (SW)
unnamed: D11.2 (A), R13.2
unnamed: D12.2 (A), R14.2
unnamed: D13.2 (A), R40.2
unnamed: D14.1 (K), R15.1
unnamed: D15.2 (A), R42.2
unnamed: D16.2 (A), R43.2
unnamed: D17.2 (A), R44.2
unnamed: D18.2 (A), R45.2
unnamed: D19.2 (A), R46.2
unnamed: D20.2 (A), R47.2
unnamed: D21.2 (A), R48.2
unnamed: D22.1 (K), R24.1
unnamed: D24.2 (A), R53.2
unnamed: D25.2 (A), R54.2
unnamed: D26.2 (A), R55.2
unnamed: JP1.1 (A), R17.2
unnamed: Q1.3 (G), R3.2
unnamed: Q2.3 (G), R4.2
unnamed: Q5.3 (G), R19.2
unnamed: Q6.3 (G), R22.2
unnamed: Q8.3 (G), R60.2
unnamed: Q9.3 (G), R61.2
unnamed: Q10.3 (G), R62.2
unnamed: Q11.3 (G), R63.2
unnamed: R1.2, U1.7
unnamed: R2.2, U1.5
unnamed: R3.1, R5.1, U1.9
unnamed: R4.1, R6.1, U1.11
unnamed: R7.2, R8.1
unnamed: R10.2, R11.1
unnamed: R18.2, U1.3
unnamed: R19.1, R20.1, U1.13
unnamed: R21.2, U1.1
unnamed: R22.1, R23.1, U1.15
unnamed: R56.2, U5.5
unnamed: R57.2, U5.3
unnamed: R58.2, U5.1
unnamed: R59.2, U5.7
unnamed: R60.1, R64.1, U5.11
unnamed: R61.1, R65.1, U5.13
unnamed: R62.1, R66.1, U5.15
unnamed: R63.1, R67.1, U5.9
unnamed: C2.1, R8.2, R9.2, U2.3 (IN₋)
unnamed: R16.2, U3.31 (PB8)
unnamed: C7.1, R11.2, R12.2, U7.3 (IN₋)
OUT1: D1.2 (A), J1.1, Q1.1 (D), Q1.2 (D), Q1.5 (D), Q1.6 (D)
OUT2: D2.2 (A), J2.1, Q2.1 (D), Q2.2 (D), Q2.5 (D), Q2.6 (D)
OUT3: D3.2 (A), J9.1, Q5.1 (D), Q5.2 (D), Q5.5 (D), Q5.6 (D)
OUT4: D4.2 (A), J10.1, Q6.1 (D), Q6.2 (D), Q6.5 (D), Q6.6 (D)
OUT5: D27.2 (A), J16.1, Q8.1 (D), Q8.2 (D), Q8.5 (D), Q8.6 (D)
OUT6: D28.2 (A), J17.1, Q9.1 (D), Q9.2 (D), Q9.5 (D), Q9.6 (D)
OUT7: D29.2 (A), J18.1, Q10.1 (D), Q10.2 (D), Q10.5 (D), Q10.6 (D)
OUT8: D30.2 (A), J19.1, Q11.1 (D), Q11.2 (D), Q11.5 (D), Q11.6 (D)
SWCLK: J7.3, U3.24 (PA14)
SWDIO: J7.1, U3.23 (PA13)
TIM2_CH1: U3.5 (PA0)
TIM2_CH2: U3.6 (PA1)
TIM2_CH3: U3.7 (PA2)
TIM2_CH4: U3.8 (PA3)
UART_RX: J8.1, U3.30 (PB7)
UART_TX: J8.3, U3.29 (PB6)
VCC: C28.1, F1.1, F2.1, J3.1, R42.1, U6.1 (VIN)
VCC_1: C1.1, C14.1, D14.2 (A), F1.2, L1.1, U2.4 (EN), U2.5 (V⁺)
VCC_2: C6.1, C13.1, D22.2 (A), F2.2, L2.1, U7.4 (EN), U7.5 (V⁺)
fan: U3.13 (PB0)

Notes on the sheet:
STLink
リセットSW
LED
電源入力
solenoid
レギュレータ
CAN
CANトランシーバー
UART
Vout = ((47+2.4)/2.2+1) = 23.45
DCDC
STM32

Board: 4 copper layers, 90.0 x 70.0 mm, 140 parts (3 on the bottom side), 89 nets.

File trinity-devices-controller_24V/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C6",0805,2,10uf,
"C10, C3, C4, C5, C8, C9",1210,6,10uf,
"C11, C12, C13, C14",CP_Radial_D10.0mm_P5.00mm,4,470uf,
"C2, C7",0603,2,10n,
"C20, C21, C22, C23, C24, C25, C26",0603,7,0.1u,
C27,0603,1,0.47u,
C28,0603,1,1uf,
C29,0603,1,0.1uf,
"D1, D10, D2, D27, D28, D29, D3, D30, D4, D9",SOD-123FL,10,SS2040FL,
"D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D24, D25, D26, D5, D6, D7, D8",0603,19,LED,
"F1, F2",1206,2,SF-1206FP100-2,
IC2,SOIC127P600X175-8N,1,MCP2562,
"J1, J10, J16, J17, J18, J19, J2, J9",JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,8,xh2pin,
"J3, J4",PV_3,2,Conn_01x01_Pin,
"J5, J6, J8",JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal,3,Conn_01x04,
J7,PinHeader_1x04_P2.54mm_Vertical,1,Conn_01x04_Pin,
JP1,TestPoint_2Pads_Pitch2.54mm_Drill0.8mm,1,Jumper_2_Open,
"L1, L2",L_Taiyo-Yuden_MD-5050,2,10uH,
"Q1, Q10, Q11, Q2, Q5, Q6, Q8, Q9",TSOP6F,8,SSM6K819R,
"R1, R16, R18, R2, R20, R21, R23, R5, R56, R57, R58, R59, R6, R64, R65, R66, R67",0603,17,10k,
"R10, R7",0603,2,47k,
"R11, R8",0603,2,2.4k,
"R12, R9",0603,2,2.2k,
"R13, R14, R15, R24, R32, R33, R34, R35, R40, R42, R43, R44, R45, R46, R47, R48, R53, R54, R55",0603,19,1k,
R17,0603,1,120,
"R19, R22, R3, R4, R60, R61, R62, R63",0603,8,100,
SW1,switch_TVAF06-A020B-R,1,SW_Push,
"U1, U5",SOIC-16_4.55x10.3mm_P1.27mm,2,TLP293-4,
"U2, U7",SOT-89-5_Handsoldering,2,NJW4132U2-B,
U3,LQFP-32_7x7mm_P0.8mm,1,STM32G431K8Tx,
U4,SOT-23-5_HandSoldering,1,NJM12888F33,
U6,TO-252-2,1,NJM7812SDL1,

## Code that names these connections

File trinity-devices-controller.ioc (part):

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Mcu.Name=STM32G431K(6-8-B)Tx
Mcu.Package=LQFP32
Mcu.UserName=STM32G431K8Tx
PA0.Signal=S_TIM2_CH1
PA1.Signal=S_TIM2_CH2
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=IN7
PA10.Signal=GPIO_Output
PA11.Mode=FDCAN_Activate
PA11.Signal=FDCAN1_RX
PA12.Mode=FDCAN_Activate
PA12.Signal=FDCAN1_TX
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA15.GPIOParameters=GPIO_Label
PA15.GPIO_Label=LED2
PA15.Signal=GPIO_Output
PA2.Signal=S_TIM2_CH3
PA3.Signal=S_TIM2_CH4
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=IN1
PA4.Signal=GPIO_Output
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=IN2
PA5.Signal=GPIO_Output
PA6.GPIOParameters=GPIO_Label
PA6.GPIO_Label=IN3
PA6.Signal=GPIO_Output
PA7.GPIOParameters=GPIO_Label
PA7.GPIO_Label=IN4
PA7.Signal=GPIO_Output
PA8.GPIOParameters=GPIO_Label
PA8.GPIO_Label=IN5
PA8.Signal=GPIO_Output
PA9.GPIOParameters=GPIO_Label
PA9.GPIO_Label=IN6
PA9.Signal=GPIO_Output
PB0.GPIOParameters=GPIO_Label
PB0.GPIO_Label=POWER_SW
PB0.Signal=GPIO_Output
PB3.GPIOParameters=GPIO_Label
PB3.GPIO_Label=LED3
PB3.Signal=GPIO_Output
PB4.GPIOParameters=GPIO_Label
PB4.GPIO_Label=LED1
PB4.Signal=GPIO_Output
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=IN8
PB5.Signal=GPIO_Output
PB6.Mode=Asynchronous
PB6.Signal=USART1_TX
PB7.Mode=Asynchronous
PB7.Signal=USART1_RX
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=128000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log (part)

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2026-05-03 回路図完成
2026-05-04 配置、配線完了
2026-05-04 ビア以外完成
2026-05-04 完成、ガーバー作成完了
2026-05-16 VCCのトラブル修正、仕様の一部を変更
2026-05-19 feat:プロジェクトファイル作成
2026-05-19 feat:初期コード生成
2026-05-19 feat:gn10-canの対か
2026-05-19 feat:appライブラリ作成
2026-05-19 docs:READMEを作成
2026-05-19 電磁弁の個数変更
2026-05-21 シルク、ビアの修正
2026-05-25 ガーバ出力
2026-05-25 feat:動作テスト
2026-06-09 feat:solenoidの値をfdcanで受け取るコード書いた
2026-06-09 feat;繰り返し電磁弁が動くのを止めた
2026-06-10 chore:solenoidのクラスを入れた
2026-06-10 chore:writepinにして受け取った値をキャストした
2026-06-10 feat:canbus.updataを入れた
